# Keil uVision project timeevent.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33LC02X FMSH
  pack: Keil.FM33LC0XX_DFP.1.0.4
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: timeevent +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FM33LC0XX,
  c include: ..\..\..\MyOs;.\;.\Drivers\FM33LC0xx_LL_Driver\Inc;.\Drivers\CMSIS\Device\FM\FM33xx\Include
  memory RVCT4: ROM 0x1800 size 0x1e000
  memory RVCT5: ROM 0x1f800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x5800
  memory RVCT10: RAM 0x20005800 size 0x800
  group Src
    ./: main.c hal.c timealarm.c sx1262.c softtimer.c cmdthd.c halthd.c dealerthd.c thd.c maclayer.c netthd.c
    ./Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
    ./Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
  group Os
    ../../../MyOs/: evtos.c
  group driver
    ./Drivers/FM33LC0xx_LL_Driver/Src/: fm33lc0xx_ll_adc.c fm33lc0xx_ll_aes.c fm33lc0xx_ll_atim.c fm33lc0xx_ll_bstim.c fm33lc0xx_ll_comp.c fm33lc0xx_ll_crc.c fm33lc0xx_ll_dma.c fm33lc0xx_ll_flash.c fm33lc0xx_ll_gpio.c fm33lc0xx_ll_gptim.c fm33lc0xx_ll_hdiv.c fm33lc0xx_ll_i2c.c fm33lc0xx_ll_iwdt.c fm33lc0xx_ll_lcd.c fm33lc0xx_ll_lptim.c fm33lc0xx_ll_lpuart.c fm33lc0xx_ll_opa.c fm33lc0xx_ll_pmu.c fm33lc0xx_ll_rcc.c fm33lc0xx_ll_rng.c fm33lc0xx_ll_rtc.c fm33lc0xx_ll_spi.c fm33lc0xx_ll_svd.c fm33lc0xx_ll_u7816.c fm33lc0xx_ll_uart.c fm33lc0xx_ll_wwdt.c
